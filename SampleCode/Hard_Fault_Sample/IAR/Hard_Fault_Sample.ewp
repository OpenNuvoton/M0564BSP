# IAR project Hard_Fault_Sample.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0564AE series Nuvoton M0564AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\M0564\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hard_Fault_Sample.bin
  ILINK.IlinkOutputFile: Hard_Fault_Samplet.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M0564/Source/IAR/: startup_M0564.s
    ../../../Library/Device/Nuvoton/M0564/Source/: system_M0564.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
