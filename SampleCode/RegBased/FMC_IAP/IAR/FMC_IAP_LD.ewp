# IAR project FMC_IAP_LD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0564AE series Nuvoton M0564AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M0564\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_IAP_LD.bin
  ILINK.IlinkOutputFile: FMC_IAP_LD.out
  ILINK.IlinkIcfFile: FMC_IAP_LD.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0564/Source/IAR/: startup_M0564.s
    ../../../../Library/Device/Nuvoton/M0564/Source/: system_M0564.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main_LD.c
