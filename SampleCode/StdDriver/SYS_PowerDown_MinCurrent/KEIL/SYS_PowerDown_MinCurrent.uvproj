# Keil uVision project SYS_PowerDown_MinCurrent.uvproj, settings and files
target SYS_PowerDown_MinCurrent (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M0564VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SYS_PowerDown_MinCurrent
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M0564\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_M0564.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0564/Source/ARM/: startup_M0564.s
    ../../../../Library/Device/Nuvoton/M0564/Source/: system_M0564.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c gpio.c sys.c uart.c
