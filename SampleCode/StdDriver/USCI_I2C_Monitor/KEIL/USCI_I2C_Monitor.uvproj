# Keil uVision project USCI_I2C_Monitor.uvproj, settings and files
target USCI_I2C_Monitor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M0564VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USCI_I2C_Monitor
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\CMSIS\CM0\CoreSupport;..\..\..\..\Library\Device\Nuvoton\M0564\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_M0564.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0564/Source/ARM/: startup_M0564.s
    ../../../../Library/Device/Nuvoton/M0564/Source/: system_M0564.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usci_i2c.c clk.c uart.c i2c.c
