# IAR project USCI_I2C_Monitor.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M0564AE series Nuvoton M0564AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M0564\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USCI_I2C_Monitor.bin
  ILINK.IlinkOutputFile: USCI_I2C_Monitor.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0564/Source/IAR/: startup_M0564.s
    ../../../../Library/Device/Nuvoton/M0564/Source/: system_M0564.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c usci_i2c.c
  group User
    ../: main.c
