# Keil uVision project SmartCardLib.uvproj, settings and files
target SmartCardLib (ARM-ADS)
  device: M0564VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SmartCardLib +hex (library)
  AfterMake: cmd.exe /C copy /Y obj\SmartCardLib.lib ..\..\SmartCardLib_Keil.lib
  c flags: OneElfS=1
  c include: ..\..\..\CMSIS\Include;..\..\..\Device\Nuvoton\M0564\Include;..\..\..\StdDriver\inc;..\..\..\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../: sclib_util.c sclib_api.c sclib_t0protocol.c sclib_t1protocol.c
